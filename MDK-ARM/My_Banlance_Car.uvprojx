# Keil uVision project My_Banlance_Car.uvprojx, settings and files
target My_Banlance_Car (6220000::V6.22::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: My_Banlance_Car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,ARM_MATH_CM3
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./Driver;./System;./Mask;./IMU;../Middlewares/ST/ARM/DSP/Inc;.\Beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Driver
    ./Driver/: Driver.c Driver.h Driver_config.c Driver_config.h Driver_Encoder.c Driver_Encoder.h Driver_pwm.c Driver_pwm.h pid.c pid.h
  group System
    ./System/: encoder.c encoder.h pwm.c pwm.h serial.c serial.h tim_it.c tim_it.h iic.c iic.h my_delay.c my_delay.h gpio_it.c gpio_it.h my_gpio.c my_gpio.h
  group IMU
    ./IMU/: mpu6050.c mpu6050.h mpu6050_config.c mpu6050_config.h mpu6050_iic.c mpu6050_iic.h
  group Mask
    ./Mask/: Mask.c Mask.h Car.c Car.h
  group Beep
    ./Beep/: Beep.c Beep.h Beep_config.c Beep_config.h Beep_gpio.c Beep_gpio.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM3l_math.lib
software components: CMSIS:CORE 6.1.0
